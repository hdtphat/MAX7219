# Keil uVision project max7219_stm32f4.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: max7219_stm32f4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c System_Clock.c System_Clock.h SPI1_Lib.c SPI1_Lib.h MAX7219.c MAX7219.h Waste_Time.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
